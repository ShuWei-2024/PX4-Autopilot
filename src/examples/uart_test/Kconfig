## src/examples/uart_test/Kconfig
```kconfig
menuconfig EXAMPLES_UART_TEST
	bool "uart_test"
	default n
	---help---
		Enable support for uart_test
```
